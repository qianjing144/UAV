# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: project +hex
  group Source Group 1
    ./Code/: I2C.c I2C.h LPS22HH.c LPS22HH.h main.c UART.c UART.h SBUS.c SBUS.h timer.c timer.h MPU6050.c MPU6050.h QMC5883L.c QMC5883L.h motor.c motor.h PID.c PID.h main.h
    ./: STC32_FPMU_HUGE_V1.0.LIB
  group New Group
    ./Debugware/: oled.c oled.h oledfont.c oledfont.h
